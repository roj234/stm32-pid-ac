# Keil uVision project STM32-AC.uvprojx, settings and files
target STM32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-AC
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\AC;.\Common
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group PID空调
    ./AC/: io.c main.c render.c input.h render.h config.c config.h
  group 公共
    ./Common/: lcd.h ui.h util.h lcd.c ui.c util.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0
